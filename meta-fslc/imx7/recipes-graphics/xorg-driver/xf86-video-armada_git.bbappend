SRC_URI_remove = " \
    git://git.armlinux.org.uk/cgit/xf86-video-armada.git;branch=unstable-devel;protocol=http;name=armada \
"

SRC_URI_append = " \
    git://github.com/VCTLabs/xf86-video-armada.git;branch=unstable-devel;protocol=http;name=armada \
"
