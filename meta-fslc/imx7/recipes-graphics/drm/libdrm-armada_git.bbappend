SRC_URI_remove = "git://git.armlinux.org.uk/~rmk/libdrm-armada.git"
SRC_URI_append = " git://github.com/g0hl1n/libdrm-armada.git;protocol=http"
