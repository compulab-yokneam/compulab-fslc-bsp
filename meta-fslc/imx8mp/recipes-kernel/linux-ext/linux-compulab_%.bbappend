linux-compulab-ext.inc